UBRANCH = "npcm7xx"
SRC_URI = "git://github.com/Nuvoton-Israel/u-boot.git;branch=${UBRANCH}"
SRCREV = "v2015.10-npcm7xx-20180608"
PV .= "+.${UBRANCH}.+"
