SUMMARY = "Nuvoton Phosphor DBUS to REST WSGI Application"
DESCRIPTION = "Nuvoton Phosphor DBUS to REST WSGI Application."

SRCREV = "bec10c202e2484fd36070ae4be26ddc2bd7267d1"
