SUMMARY = "Nuvoton Phosphor Rocket startup script"
DESCRIPTION = "Nuvoton Phosphor Rocket startup script."

SRCREV = "bec10c202e2484fd36070ae4be26ddc2bd7267d1"
