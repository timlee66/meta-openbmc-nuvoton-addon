FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://evb-npcm750-addon.cfg"
SRC_URI += "file://0001-ntil-linux-npcm750-add-vcd-and-ece-driver.patch"
